<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo_F446RE_software_reset.ewp</path>
  </project>
  <batchBuild />
</workspace>
